# Keil uVision project project1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source Group 1
    ./: main.cpp
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
